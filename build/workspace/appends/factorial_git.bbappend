inherit externalsrc
EXTERNALSRC = "/home/wsl/poky/build/workspace/sources/factorial"
EXTERNALSRC_BUILD = "/home/wsl/poky/build/workspace/sources/factorial"

# initial_rev .: 27134a05d6b5aa06a474bc0002f6541550ac51e0
